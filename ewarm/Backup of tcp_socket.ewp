# IAR project Backup of tcp_socket.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; xUSER_INPUT_ENABLE; UART1_PRINTF; HAL_OLED; HAL_KEY; HAL_LED; ENABLE_JPEG; VGA_FRAME
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tcp_socket.bin
  ILINK.IlinkOutputFile: tcp_socket.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: board_key.c board_key.h button_if_amo.c button_if_amo.h camera_app.c camera_app.h hal_lcd.c hal_lcd.h i2cconfig.c i2cconfig.h main.c mt9d111.c mt9d111.h pinmux.c uart_if_amo.c uart_if_amo.h
    ../../common/: gpio_if.c gpio_if.h startup_ewarm.c timer_if.c timer_if.h udma_if.c udma_if.h
